# The main recipe in meta-boot2qt points to a url for this package which is
# obsolete. It has been fixed in warrior but not in QtAS_5.13.
PYPI_SRC_URI = "http://152.3.102.14/pypi/packages/36/48/743fa68f043bf8cab48e1fa70503a49c18ade92c543f7517af2ab3fdfaff/watchdog3-0.8.5.tar.gz"


