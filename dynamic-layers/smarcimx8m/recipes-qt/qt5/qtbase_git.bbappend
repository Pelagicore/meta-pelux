PACKAGECONFIG_append = " eglfs "
