RDEPENDS_${PN}_remove = " \
    qtwebkit-dev \
"
