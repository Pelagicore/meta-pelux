PACAGECONFIG_append = " eglfs "
