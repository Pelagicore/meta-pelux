require pelux-image-update.inc
