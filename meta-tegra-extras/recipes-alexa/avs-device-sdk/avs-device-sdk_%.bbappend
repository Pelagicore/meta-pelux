# build without snowboy support since build fails with
# the aarch64 binaries it provides
PACKAGECONFIG_remove = " kittai "
