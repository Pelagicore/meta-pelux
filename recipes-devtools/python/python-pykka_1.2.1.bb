SUMMARY = "Pykka is a Python implementation of the actor model"
HOMEPAGE = "https://www.pykka.org/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "50e4f2877c0825788219bc442a86a293"
SRC_URI[sha256sum] = "e847ffeadee49b563426ab803e8eee67264d773e38ca14763fdcda56411e3c11"

PYPI_PACKAGE = "Pykka"
inherit pypi setuptools
