#
#   Copyright (C) 2017 Pelagicore AB
#

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://fstab"

