
# Without support for glib-2.0-native, the calls to glib-mkenums will fail

DEPENDS += " glib-2.0-native "
