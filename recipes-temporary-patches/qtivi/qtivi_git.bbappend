DEPENDS += "qtquickcontrols2"
DEPENDS_class-native += "qtremoteobjects"
