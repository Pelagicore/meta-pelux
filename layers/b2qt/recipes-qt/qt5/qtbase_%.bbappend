
#
# Remove gbm support if we're building for rpi
#
PACKAGECONFIG_remove_rpi = "gbm"
