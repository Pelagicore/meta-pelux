PACKAGECONFIG[sdl2] = "-no-feature-sdl2"
